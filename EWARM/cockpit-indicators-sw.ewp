# IAR project cockpit-indicators-sw.ewp, settings and files
configuration cockpit-indicators-sw (ARM, debug)
  General.OGChipSelectEditMenu: STM32C092FC ST STM32C092FC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32C092xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32C0xx_HAL_Driver/Inc; ../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32C0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cockpit-indicators-sw.hex
  ILINK.IlinkOutputFile: cockpit-indicators-sw.out
  ILINK.IlinkIcfFile: stm32c092xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32c092xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c fdcan.c tim.c usart.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Drivers/STM32C0xx_HAL_Driver
    ../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_exti.c stm32c0xx_hal_fdcan.c stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c stm32c0xx_hal_uart.c stm32c0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32c0xx.c
